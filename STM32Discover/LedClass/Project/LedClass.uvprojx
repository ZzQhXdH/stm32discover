# Keil uVision project LedClass.uvprojx, settings and files
target LedClass (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LedClass
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx
  c misc: --cpp11
  c include: ..\CMSIS;..\System;..\..\LedClass
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../StartUp/: startup_stm32f429_439xx.s
  group System
    ../System/: system_stm32f4xx.c
  group User
    ../User/: app.cpp main.cpp
  group Periph
    ../Periph/: GpioClass.h SysClockClass.h SerialPortClass.h
  group Device
    ../Device/: LedClass.h KeyClass.h
